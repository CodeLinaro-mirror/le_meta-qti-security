SUMMARY = "QTI mink opensource packagegroup"

LICENSE = "BSD-3-Clause"
PACKAGE_ARCH = "${MACHINE_ARCH}"

inherit packagegroup
