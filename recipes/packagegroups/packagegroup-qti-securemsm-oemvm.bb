SUMMARY = "QTI securemsm opensource packagegroup for oemvm"

LICENSE = "BSD-3-Clause-Clear"
PACKAGE_ARCH = "${MACHINE_ARCH}"

inherit packagegroup
